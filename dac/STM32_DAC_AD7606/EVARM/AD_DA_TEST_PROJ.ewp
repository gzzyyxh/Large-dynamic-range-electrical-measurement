# IAR project AD_DA_TEST_PROJ.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ../; ../Libraries\STM32F10x_StdPeriph_Driver\inc; ../Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ../Libraries\CMSIS\CM3\CoreSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COLIN_STM32LED.hex
  ILINK.IlinkOutputFile: STM32LED.out
  ILINK.IlinkIcfFile: G:\ColinZhao_Designed_Files\TAOBAO_MODULE_TEST_CODE\STM32_DAC8562-3\EVARM\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group EVARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group User
    ../: main.c stm32f10x_it.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_tim.c
